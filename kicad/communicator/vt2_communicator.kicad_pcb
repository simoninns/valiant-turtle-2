# Repository simoninns/valiant-turtle-2 (continued)

## KiCad design robot/kicad/mainboard/valiant-turtle-2.kicad_pcb (continued)

Board: 4 copper layers, 133.1 x 126.6 mm, 55 parts (0 on the bottom side), 50 nets.

## KiCad design robot/kicad/valiant-turtle-2.kicad_pcb

Board: 2 copper layers, 133.1 x 126.6 mm, 64 parts (0 on the bottom side), 54 nets.

Parts:
A1, A2: DRV8825_Breakout; Pololu_Breakout-16_15.2x20.3mm
C1, C5, C9, C12: 100nF; C_0805_2012Metric_Pad1.18x1.45mm_HandSolder
C2, C3, C4, C6: 100uF; CP_Elec_8x6.2
C7: 1uF; C_0805_2012Metric_Pad1.18x1.45mm_HandSolder
C8: 1000uF; CP_Elec_10x10.5
C10, C11: 10uF Tant; CP_EIA-3528-21_Kemet-B_Pad1.50x2.35mm_HandSolder
D1: SS34; C_0805_2012Metric_Pad1.18x1.45mm_HandSolder
D2: Power LED; LED_0805_2012Metric_Pad1.15x1.40mm_HandSolder
H1, H2, H3: Body_MountingHole; MountingHole_3.2mm_M3
H4, H5, H6, H7: OLED_MountingHole; MountingHole_2.7mm_M2.5
J1, J7: Conn_01x01; PinHeader_1x01_P2.54mm_Vertical
J2: Conn_01x02; PinHeader_1x02_P2.54mm_Vertical
J3: Qwiic; JST_SH_SM04B-SRSS-TB_1x04-1MP_P1.00mm_Horizontal
J4: USART; PinHeader_1x03_P2.54mm_Vertical
J5: OLED 128x64 SSD1106; PinHeader_1x04_P2.54mm_Vertical
J6: Conn_01x05; PinHeader_1x05_P2.54mm_Vertical
J8: Pen_Servo; PinHeader_1x03_P2.54mm_Vertical
J9: Left Motor; JST_XH_B4B-XH-A_1x04_P2.50mm_Vertical
J10: Right Motor; JST_XH_B4B-XH-A_1x04_P2.50mm_Vertical
J11: Battery; JST_XH_B3B-XH-A_1x03_P2.50mm_Vertical
J12: Power_Switch; JST_XH_B2B-XH-A_1x02_P2.50mm_Vertical
J13: Power Header; PinHeader_1x03_P2.54mm_Vertical
J14: RGB LED Eyeballs; JST_XH_B7B-XH-A_1x07_P2.50mm_Vertical
L1: 100uH 5A; L_Bourns_SRP1770TA_16.9x16.9mm
Q1, Q2, Q3: BSS138; SOT-23
R1, R2, R3, R4: 10K; R_0805_2012Metric_Pad1.20x1.40mm_HandSolder
R5, R6, R10, R14: 1K; R_0805_2012Metric_Pad1.20x1.40mm_HandSolder
R7, R11, R15: 100K; R_0805_2012Metric_Pad1.20x1.40mm_HandSolder
R8, R9: 150R; R_0805_2012Metric_Pad1.20x1.40mm_HandSolder
R12, R13, R16, R17: 100R; R_0805_2012Metric_Pad1.20x1.40mm_HandSolder
SW1: Left_Button; SW_Push_1P1T_NO_6x6mm_H9.5mm
SW2: Right_Button; SW_Push_1P1T_NO_6x6mm_H9.5mm
U1: RaspberryPi_Pico_W; RaspberryPi_Pico_Common
U2: LM2576S-5; TO-263-5_TabPin3
U3: INA260; TSSOP-16_4.4x5mm_P0.65mm
U4: LM1117MP-3.3; SOT-223-3_TabPin2

Connections:
+3V3: C1.1, C7.1, C11.1, C12.1, J3.3, J5.2, J13.1, R1.1, R2.1, R3.2, R4.2, U3.10 (VS), U4.2 (VO)
+5V: C2.1, C8.1, C9.1, C10.1, J8.2, J13.2, J14.4, L1.2, R5.1, U1.39 (VSYS), U2.4 (FB), U4.3 (VI)
+12V: A1.16 (VMOT), A2.16 (VMOT), C3.1, C4.1, C5.1, C6.1, U2.1 (VIN), U3.14 (IN-), U3.15 (IN-), U3.16 (IN-)
/NEMA 17 Stepper Drivers/Enable: A1.5 (~RST), A1.6 (~SLEEP), A2.5 (~RST), A2.6 (~SLEEP), U1.9 (GPIO6)
/NEMA 17 Stepper Drivers/LM_Dir: A1.8 (DIR), U1.5 (GPIO3)
/NEMA 17 Stepper Drivers/LM_Step: A1.7 (STEP), U1.4 (GPIO2)
/NEMA 17 Stepper Drivers/RM_Dir: A2.8 (DIR), U1.7 (GPIO5)
/NEMA 17 Stepper Drivers/RM_Step: A2.7 (STEP), U1.6 (GPIO4)
GND: A1.1 (~EN), A1.2 (M0), A1.3 (M1), A1.4 (M2), A1.9 (GND), A1.15 (GND), A2.1 (~EN), A2.2 (M0), A2.3 (M1), A2.4 (M2), A2.9 (GND), A2.15 (GND), C1.2, C2.2, C3.2, C4.2, C5.2, C6.2, C7.2, C8.2, C9.2, C10.2, C11.2, C12.2, D1.2 (A), D2.1 (K), J3.4, J4.3, J5.1, J8.3, J11.2, J11.3, J13.3, Q1.2 (S), Q2.2 (S), Q3.2 (S), R7.2, R11.2, R15.2, SW1.1, SW2.1, U1.3 (GND), U1.8 (GND), U1.13 (GND), U1.18 (GND), U1.23 (GND), U1.28 (GND), U1.33 (AGND), U1.38 (GND), U2.3 (GND), U2.5 (~ON/OFF), U3.4 (A1), U3.5 (A0), U3.6 (GND), U3.11 (GND), U4.1 (GND)
unnamed: A1.12 (A1), J9.3
unnamed: A1.11 (A2), J9.1
unnamed: A1.13 (B1), J9.2
unnamed: A1.14 (B2), J9.4
unnamed: A2.12 (A1), J10.3
unnamed: A2.11 (A2), J10.1
unnamed: A2.13 (B1), J10.2
unnamed: A2.14 (B2), J10.4
unnamed: D1.1 (K), L1.1, U2.2 (OUT)
unnamed: D2.2 (A), R5.2
unnamed: J1.1, U1.10 (GPIO7)
unnamed: J2.1, U1.20 (GPIO15)
unnamed: J2.2, U1.19 (GPIO14)
unnamed: J4.1, U1.1 (GPIO0)
unnamed: J4.2, U1.2 (GPIO1)
unnamed: J6.1, U1.22 (GPIO17)
unnamed: J6.2, U1.24 (GPIO18)
unnamed: J6.3, U1.25 (GPIO19)
unnamed: J6.4, U1.26 (GPIO20)
unnamed: J6.5, U1.27 (GPIO21)
unnamed: J7.1, U1.32 (GPIO27_ADC1)
unnamed: J11.1, J12.2
unnamed: J12.1, U3.1 (IN+), U3.2 (IN+), U3.3 (IN+), U3.12 (VBUS)
unnamed: J14.1, R8.1
unnamed: J14.2, R12.1
unnamed: J14.3, R16.1
unnamed: J14.5, R9.1
unnamed: J14.6, R13.1
unnamed: J14.7, R17.1
unnamed: Q1.3 (D), R8.2, R9.2
unnamed: Q1.1 (G), R6.2, R7.1
unnamed: Q2.3 (D), R12.2, R13.2
unnamed: Q2.1 (G), R10.2, R11.1
unnamed: Q3.3 (D), R16.2, R17.2
unnamed: Q3.1 (G), R14.2, R15.1
unnamed: SW1.2, U1.16 (GPIO12)
unnamed: SW2.2, U1.17 (GPIO13)
PWM_Blue: R14.1, U1.31 (GPIO26_ADC0)
PWM_Green: R10.1, U1.29 (GPIO22)
PWM_Red: R6.1, U1.21 (GPIO16)
PWM_Servo: J8.1, U1.34 (GPIO28_ADC2)
SCL0: J5.3, R3.1, U1.12 (GPIO9), U3.9 (SCL)
SCL1: J3.1, R2.2, U1.15 (GPIO11)
SDA0: J5.4, R4.1, U1.11 (GPIO8), U3.8 (SDA)
SDA1: J3.2, R1.2, U1.14 (GPIO10)

## KiCad design acorn_userport_adapter/kicad/parallel_adapter.kicad_pcb

Board: 2 copper layers, 39.2 x 32.0 mm, 4 parts (0 on the bottom side), 11 nets.

Parts:
H1, H2: MountingHole; MountingHole_3.2mm_M3
J1: BBC Micro Userport; IDC-Header_2x10_P2.54mm_Horizontal
J2: DA15_Valiant_Parallel; DSUB-15_Female_Horizontal_P2.77x2.84mm_EdgePinOffset9.90mm_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

Connections:
GND: J1.5, J1.7, J1.9, J1.11, J1.13, J1.15, J1.17, J1.19, J2.0 (PAD), J2.9, J2.10
unnamed: J1.2, J2.14
unnamed: J1.4, J2.15
unnamed: J1.6, J2.1
unnamed: J1.8, J2.2
unnamed: J1.10, J2.3
unnamed: J1.12, J2.4
unnamed: J1.14, J2.5
unnamed: J1.16, J2.6
unnamed: J1.18, J2.7
unnamed: J1.20, J2.8

## Code that names these connections

File firmware/stepper/main.py:

# Stepper motor control test program
import library.logging as logging
from machine import Pin
import time

from drv8825 import Drv8825
from stepper import Stepper
from pulse_generator import PulseGenerator

_GPIO_LM_STEP = const(2)
_GPIO_RM_STEP = const(3)
_GPIO_LM_DIR = const(4)
_GPIO_RM_DIR = const(5)
_GPIO_ENABLE = const(6)
_GPIO_M0 = const(12)
_GPIO_M1 = const(13)
_GPIO_M2 = const(14)

def main():
    logging.basicConfig(level=logging.DEBUG, format='%(asctime)s - %(levelname)s - %(message)s')

    # Main test function
    left_step_pin = Pin(_GPIO_LM_STEP, Pin.OUT)
    left_direction_pin = Pin(_GPIO_LM_DIR, Pin.OUT)
    right_step_pin = Pin(_GPIO_RM_STEP, Pin.OUT)
    right_direction_pin = Pin(_GPIO_RM_DIR, Pin.OUT)

    drv8825_enable_pin = Pin(_GPIO_ENABLE, Pin.OUT)
    drv8825_m0_pin = Pin(_GPIO_M0, Pin.OUT)
    drv8825_m1_pin = Pin(_GPIO_M1, Pin.OUT)
    drv8825_m2_pin = Pin(_GPIO_M2, Pin.OUT)

    # The DRV8825 driver is shared between the two stepper motors
    drv8825 = Drv8825(drv8825_enable_pin, drv8825_m0_pin, drv8825_m1_pin, drv8825_m2_pin)
    drv8825.set_steps_per_revolution(800)
    drv8825.set_enable(False)

    # Create the left and right stepper motor instances
    left_stepper = Stepper(drv8825, left_step_pin, left_direction_pin, True)
    #right_stepper = Stepper(drv8825, right_step_pin, right_direction_pin, False)

    while True:
        # Set forwards
        left_stepper.set_direction_forwards()
        logging.debug("Main - Forwards")
        drv8825.set_enable(True)

        logging.debug("Main - Running")
        left_stepper.set_acceleration_spsps(16)
        left_stepper.set_target_speed_sps(800)
        left_stepper.move(800 * 4)

        while left_stepper.is_busy:
            time.sleep_ms(100)

        logging.debug("Main - Waiting...")
        drv8825.set_enable(False)
        time.sleep_ms(5000)

main()

## Commit log (part)

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2024-01-12 Added initial mock up of OLED display and buttons to the PCB in OpenSCAD
2024-01-12 Corrected a couple of small issues
2024-01-13 Added BT library - all compiles, but probably doesn't work yet
2024-01-14 First working version of the bluetooth stack with serial port emulation
2024-01-14 First BT CLI implementation - only takes input (output is still to stdio)
2024-01-15 Added debug overlay function for printf to UART
2024-01-15 Removed old cli.h and .c files as they are no longer required
2024-01-15 Improved motor control functions, but timer isn't really working correctly yet
2024-01-16 Added basic stepper motor speed control
2024-01-18 Made the stand nicer looking
2024-01-19 Added reenforcements to the front head cutout of the shell
2024-01-20 Prevented change of motor direction when motors are running - prevented setting motors to running when not enabled
2024-08-26 Added submodule CLI library
2024-08-27 Added pen up, down and off commands to the CLI and servo control code
2024-08-27 Clean up of CLI commands to make it easier to understand
2024-08-31 Merged VT communicator project with the main project
2024-08-31 Fix style of BT code and changed CLI prompt to VT2>
2024-09-01 Added forwards and backwards commands - also fixed some bugs in stepconf.c
2024-09-03 Changed back to 800 steps/rev microstepping
2024-09-05 Correction to turning circle diameter in SCAD
2024-09-05 Added rotation degree marker to calibration guide
2024-09-06 Added light-pipes and supports for eye LEDs
2024-09-07 Changed servo holder to generate better clearance for battery pack
2024-09-08 Clean up of battery.scad
2024-09-09 Battery pack and upper/lower covers
2024-09-10 Added male battery connector and added lock to female connector cover
2024-09-10 Clean up of body scad ready for test printing (for new battery design)
2024-09-11 Added bash script to auto-generate all required STL files including support STLs
2024-09-11 Fixed battery screws for new battery design
2024-09-11 Added DXF generation for the eye PCB
2024-09-12 Added model of the BMS board PCB
2024-09-12 Corrections and improvements to battery upper cover after test printing
2024-09-13 Added basic case design for the charger
2024-09-14 Changed stand design to something that looks nicer
2024-09-16 Fixed ingress character code in bluetooth
2024-09-17 Improved memory handling around temporary lineBuffers by making them shared and malloc'd
2024-09-18 Moved CLI to stdio and debug to stderr (ready to redirect text streams to BT)
2024-09-18 Added redirection to allow CLI via bluetooth SPP channel 0
2024-09-19 New charger design around Amazon 4S USBC charging board
2024-09-20 Chnaged charger base design to allow easier battery insertion
2024-09-20 Changed light pipe design for easier printing and solved issue #23
2024-09-20 Fixed issue #28. Fixed issue #25
2024-09-20 Removed communicator STL files
2024-09-20 Added STL generation script for charger OpenSCAD model
2024-09-24 Added metric motion calculations and CLI command
2024-09-26 Added eye-left and eye-right commands to control the LEDs
2024-09-28 Fix for issue #36
2024-09-28 First battery clip design to replace BML SMT dual-battery holder
2024-09-28 Fixed dimensions to get battery clip on the upper batter case lid again. Moved BMS
2024-09-29 Fix for issue #37 - changed screws to DIN912 hex standard
2024-09-29 Added body left and right support enforcers
2024-09-30 Added resistor and cap to the eye PCB schematic
2024-10-01 Changed head and eye design to locate the 5050 LEDs in a more convenient location for better construction
2024-10-02 Fix for issue #22
2024-10-03 Fixed minor bug in pulse_generator_register_callback()
2024-10-03 Fixed minor issue with CLI and help command line spacing
2024-10-04 Moved Pico foorprints to submodule. Corrected schematic issues and general schematic clean up ready for PCB design
2024-10-04 Finished PCB design - ready for gerber generation
2024-10-05 Added aux PCB to OpenSCAD project and included DXF export to put the outline into KiCAD Removed eye kicad project (not needed) Added aux PCB KiCAD project (basically empty at the moment)
2024-10-05 Created PCB gerbers ready for ordering PCBs
2024-10-06 Added some basic UART test code to the communicator firmware
2024-10-10 Test PIO design - IR has limited range due to mA constraints
2024-10-11 redesign of head and eyes. Added mount for AUX PCB
2024-10-11 Changed aux PCB holder design a little and made it 5mm lower
2024-10-14 Added Bluetooth stack code to communicator and fixed BT COD to match between robot and communicator
2024-10-16 Added turtle ID to robot configuration
2024-10-23 Merging communicator projects together. Started reorganising communicator case
2024-10-24 Fixed communicator SCAD header messages
2024-10-24 Rotated case 90 degrees to allow more width for the communicator's connectors at the back
2024-10-24 Created gerbers for parallel adapter and communicator board
2024-10-26 Added the start of micropython firmware for the robot mainboard
2024-10-26 Some clean-up and better type checking in the classes
2024-10-27 Added DRV8825 class to robot firmware
2024-10-28 Working stepper motor class for multiple steppers
2024-10-28 Added metric to steps conversion class
2024-10-31 UART and IR_UART working with original Valiant Turtle in Communicator firmware
2024-11-01 Checking in the communcator code - all working except interrupts
2024-11-02 Working parallel to IR with original turtle (communicator)
2024-11-03 Communicator now sends both parallel and serial data to original turtle
2024-11-03 Removed old communicator firmware - moved new python firmware to the firmware/ directory
2024-11-04 Fixed header of .py files (communicator firmware) to state module purpose
2024-11-05 Move userport adapter to it's own directory and put basic openscad project in place for a case
2024-11-06 Clean up of robot BLE module for better debugging
2024-11-10 Added working robot BLE functions
2024-11-11 Changed level shift design slightly on robot mainboard - 74HC04 to 74HCT04 and 560R to 100R on output Levels look much cleaner on the oscilloscope
2024-11-11 Added stepper test and sync'd motor LEDs with stepper direction and activity
2024-11-12 More structural fixes to the BLE code - but the central/peripherial is the wrong way round...
2024-11-13 Added working battery status update to peripheral and central
2024-11-14 Bug fix to logging module and clean up of debug vs info messages
2024-11-16 Added CTS and Tx support to the communicator's 5 pin DIN connector
2024-11-18 Added command shell - still needs to be integrated into the main code though
2024-11-18 Minor typo fix
2024-11-19 Changed robot firmware to use the same logging methods as the communicator
2024-11-19 Fixes to class names PEP8 and included new class for 32-bit status flag communication
2024-11-20 Changed command communication to use 4 byte words
2024-11-20 Working communicator to robot commands over BLE - command poll now every 250ms
2024-11-21 Refactored project structure and moved directories - this is to allow better structure for libraries shared between firmwares
2024-11-22 Added class to handle velocity parameters and a new command to set the velocity in millimeters
2024-11-22 Improved robot model to allow proper left/right rendering including screws and motors
2024-11-23 Correction to readme.md
2024-11-24 Redesigned wheels to allow physical axel width calibration. Changed axel width to 224mm (was 230mm) Added position markers to the bottom of the motor bays
2024-11-24 Fix for issue #56, removed 1mm from servo horn
2024-11-24 Update to communicator scad to make PCB smaller before kicad redesign
2024-11-25 Moved the 4mm bullet connectors to non-printable parts
2024-11-26 Added command_uid to RobotCommand class as well as some minor bug fixes
2024-11-27 Harmonized command result handling. Changed parameters and status flags to 16 bit unsigned ints to preserve MTU space
2024-11-30 Added Acornsoft Logo VT2EXT extension source code plus some minor logging updates to the communicator code
2024-11-30 Minor fix to the Logo extension to correct a bug in EYES
2024-12-03 Added ir cover lock to the openscad communicator case design
2024-12-04 Merged new stepper control code into the robot firmware and removed the temporary stepper project
2024-12-06 Corrections to parallel code for new hardware. Added simple options class for new communicator option jumpers
2024-12-07 Improvements to the communicator firmware's logging
2024-12-07 Added calibration commands and fixed buggy one-shot stepper motion. No way to save calibration yet.
2024-12-08 Changed wheel design to (hopefully) make it spin more true
2024-12-08 Changed pulse generator to step both steppers from the same SM to increase the linear accuracy of the robot (by making sure both steppers pulse at the same time you remove twist from the motion)
2024-12-10 Added robot configuration with EEPROM load/save/reset
2024-12-12 Added a second shell module to the robot scad in order to play with improving the turtle shell design
2024-12-13 Mock up of the top part of the shell ready for a test print to see if it works
2024-12-13 Added the left and right wheel arches. Just needs some screw mounts
2024-12-14 Minor tidy up of the shell code
2024-12-15 fix for issue #12
2024-12-16 Some minor changes to the debugging to allow output via UART0 if required.
2024-12-18 Fix for issue #17
2024-12-18 Changed Micropython logging to picolog - this is to make it easier to avoid conflicts with the 'logging' module
2024-12-18 Fixed linux vt2comms to harmonize logging with the pico firmware
2024-12-19 Added a simple LOGO demonstration program that draws a flower
2024-12-19 Couple of bug fixes and a PDF for issue #11
2024-12-23 First pass at cartesian control commands - basically working but not quite finished yet
2024-12-25 Added simple navigation guide to documents
2024-12-27 Check-in of host code - doesn't work at the moment, but is mostly there
2024-12-28 Implemented first BLE commands with response. Fixed some bugs.
2024-12-28 Added some basic battery level monitoring with cut-off at 12V (3V per cell) - simply turns off the motors and ignores commands
2024-12-29 Made the commands synchronous and split command and battery testing. Fixed some bugs on the robot side to more cleanly disconnect BLE
2024-12-29 Fixed a bug in the BLE code that caused runtime errors if you connect, disconnect and then connect again
2024-12-30 Fixed bug - EEPROM configuration was not read when the robot powers up initially
2024-12-30 Fix to the CLI and an improvement to the calibration spreadsheet
2024-12-31 Changed heading and coordinates to the correct mathematical implementation (like python turtle). Nearly all fixed apart from the arc turns
2024-12-31 Added a robot function to draw circles smaller than the axel radius
2025-01-01 Harmonized command set with python's turtle class to make translation easier. Updated demo, cli and command tester
2025-01-01 Added a logotype (quite rough at the moment) and added a circle(step=x) command into the floor turtle abstract class
2025-01-02 Missed a small change in the last commit
2025-01-03 Added some calibration test patterns to the vt2_demo.py and added a command line switch to control the speed of both the screen and floor turtles
2025-01-04 Some fixes to the new communicator firmware and logo extension after some quick testing
2025-01-05 Changed everything to floats and then smoothed the error in the stepper.py module. This has help accuracy a lot. Stepper.py also shows the error margin (in steps) in debug - after every move
2025-01-05 Fix for issue #27 and some improvements to the vt2_demo app

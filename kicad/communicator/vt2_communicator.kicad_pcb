# Repository simoninns/valiant-turtle-2

File README.md:

# Valiant Turtle 2
The Valiant Turtle 2 is a modern re-creation of the Valiant Turtle robot from the 1980s.  The project is fully open-hardware and open-software and is designed to be 3D printed and constructed from widely available parts.

Please see the project Wiki for details of the project and for access to the project documentation.

## Project status
This project is at first release.  Please read the wiki and see YouTube for consruction videos (detailed in the wiki also).

## Author
Valiant Turtle 2 is designed and maintained by Simon Inns.

## Software License (GPLv3)

    Valiant Turtle 2 is free software: you can redistribute it and/or modify
    it under the terms of the GNU General Public License as published by
    the Free Software Foundation, either version 3 of the License, or
    (at your option) any later version.

    Valiant Turtle 2 is distributed in the hope that it will be useful,
    but WITHOUT ANY WARRANTY; without even the implied warranty of
    MERCHANTABILITY or FITNESS FOR A PARTICULAR PURPOSE.  See the
    GNU General Public License for more details.

    You should have received a copy of the GNU General Public License
    along with this program.  If not, see <http://www.gnu.org/licenses/>.

## Hardware License (Creative Commons BY-SA 4.0)
Please see the following link for details: https://creativecommons.org/licenses/by-sa/4.0/

You are free to:

Share - copy and redistribute the material in any medium or format
Adapt - remix, transform, and build upon the material
for any purpose, even commercially.

This license is acceptable for Free Cultural Works.

The licensor cannot revoke these freedoms as long as you follow the license terms.

Under the following terms:

Attribution - You must give appropriate credit, provide a link to the license, and indicate if changes were made. You may do so in any reasonable manner, but not in any way that suggests the licensor endorses you or your use.

ShareAlike - If you remix, transform, or build upon the material, you must distribute your contributions under the same license as the original.

No additional restrictions - You may not apply legal terms or technological measures that legally restrict others from doing anything the license permits.

## KiCad design kicad/communicator/vt2_communicator.kicad_pcb

Parts:
A1: RaspberryPi_Pico_W; RaspberryPi_Pico_Common
C1: 100nF; C_0805_2012Metric_Pad1.18x1.45mm_HandSolder
D1: Green; LED_D5.0mm_Horizontal_O1.27mm_Z3.0mm_Clear
D2: Blue; LED_D5.0mm_Horizontal_O1.27mm_Z3.0mm_Clear
H1, H2, H3, H4: MountingHole; MountingHole_3.2mm_M3
J1: Debug UART; PinHeader_1x03_P2.54mm_Vertical
J2: Buttons; JST_XH_B4B-XH-A_1x04_P2.50mm_Vertical
J3: Qwiic1; JST_SH_BM04B-SRSS-TB_1x04-1MP_P1.00mm_Vertical
JP1: Option_0; PinHeader_1x02_P2.54mm_Vertical
JP2: Option_1; PinHeader_1x02_P2.54mm_Vertical
JP3: Option_2; PinHeader_1x02_P2.54mm_Vertical
R1, R2, R5, R6: 10K; R_0805_2012Metric_Pad1.20x1.40mm_HandSolder
R3, R4: 220R; R_0805_2012Metric_Pad1.20x1.40mm_HandSolder

Connections:
+3V3: A1.36 (3V3), C1.2, D1.2 (A), D2.2 (A), J3.2, R1.1, R2.1, R5.1, R6.1; also elsewhere on the board
+5V: A1.39 (VSYS); also elsewhere on the board
CTS1: A1.9 (GPIO6); also elsewhere on the board
GND: A1.3 (GND), A1.8 (GND), A1.13 (GND), A1.18 (GND), A1.23 (GND), A1.28 (GND), A1.38 (GND), C1.1, J1.3, J2.4, J3.1, J3.MP (MountPin), JP1.2 (B), JP2.2 (B), JP3.2 (B); also elsewhere on the board
INT0: A1.16 (GPIO12); also elsewhere on the board
IR_LED: A1.29 (GPIO22); also elsewhere on the board
unnamed: A1.1 (GPIO0), J1.1
unnamed: A1.2 (GPIO1), J1.2
unnamed: A1.21 (GPIO16), R3.2
unnamed: A1.24 (GPIO18), R4.2
unnamed: A1.25 (GPIO19), J2.3
unnamed: A1.26 (GPIO20), J2.2
unnamed: A1.27 (GPIO21), J2.1
unnamed: A1.31 (GPIO26_ADC0), JP1.1 (A)
unnamed: A1.32 (GPIO27_ADC1), JP2.1 (A)
unnamed: A1.34 (GPIO28_ADC2), JP3.1 (A)
unnamed: D1.1 (K), R3.1
unnamed: D2.1 (K), R4.1
RTS1: A1.10 (GPIO7); also elsewhere on the board
RxD1: A1.7 (GPIO5); also elsewhere on the board
SCK0: A1.12 (GPIO9), R2.2; also elsewhere on the board
SCK1: A1.15 (GPIO11), J3.4, R6.2
SDA0: A1.11 (GPIO8), R1.2; also elsewhere on the board
SDA1: A1.14 (GPIO10), J3.3, R5.2
TxD1: A1.6 (GPIO4); also elsewhere on the board

Parts:
D3, D4, D5, D6: OSRAM SFH4557; LED_D5.0mm_Horizontal_O1.27mm_Z3.0mm_IRBlack
Q1: ZXMN3A01F; SOT-23
R7: 10K; R_0805_2012Metric_Pad1.20x1.40mm_HandSolder
R8: 100R; R_0805_2012Metric_Pad1.20x1.40mm_HandSolder
R9, R10, R11, R12: 10R; R_0805_2012Metric_Pad1.20x1.40mm_HandSolder

Connections:
+5V: R9.1, R10.1, R11.1, R12.1; also elsewhere on the board
GND: Q1.2 (S), R7.2; also elsewhere on the board
IR_LED: R7.1, R8.2; also elsewhere on the board
unnamed: D3.2 (A), D4.2 (A), D5.2 (A), D6.2 (A), R9.2, R10.2, R11.2, R12.2
unnamed: D3.1 (K), D4.1 (K), D5.1 (K), D6.1 (K), Q1.3 (D)
unnamed: Q1.1 (G), R8.1

Notes on the sheet:
10R / 4 = 2.5R (using 4 resistors to spread the current load)

Parts:
C7: 100nF; C_0805_2012Metric_Pad1.18x1.45mm_HandSolder
J5: DA15_Plug_MountingHoles; DSUB-15_Male_Horizontal_P2.77x2.84mm_EdgePinOffset9.90mm_Ho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
Q2, Q3, Q4: BSS138; SOT-23
R13, R14, R15, R16: 10K; R_0805_2012Metric_Pad1.20x1.40mm_HandSolder
U2: MCP23017_SS; SSOP-28_5.3x10.2mm_P0.65mm

Connections:
+3V3: Q2.1 (G), Q3.1 (G), Q4.1 (G), R13.1; also elsewhere on the board
+5V: C7.1, R14.1, R15.1, R16.1, U2.9 (VDD), U2.18 (~RESET); also elsewhere on the board
/Parallel Interface/BUSY: J5.14, U2.4 (GPB3)
/Parallel Interface/DAT0: J5.1, U2.21 (GPA0)
/Parallel Interface/DAT1: J5.2, U2.22 (GPA1)
/Parallel Interface/DAT2: J5.3, U2.23 (GPA2)
/Parallel Interface/DAT3: J5.4, U2.24 (GPA3)
/Parallel Interface/DAT4: J5.5, U2.25 (GPA4)
/Parallel Interface/DAT5: J5.6, U2.26 (GPA5)
/Parallel Interface/DAT6: J5.7, U2.27 (GPA6)
/Parallel Interface/DAT7: J5.8, U2.28 (GPA7)
/Parallel Interface/UN0: J5.11 (P111), U2.1 (GPB0)
/Parallel Interface/UN1: J5.12, U2.2 (GPB1)
/Parallel Interface/~ACK: J5.13, U2.3 (GPB2)
/Parallel Interface/~DATASTROBE: J5.15, U2.5 (GPB4)
GND: C7.2, J5.0 (PAD), J5.9, J5.10, U2.10 (VSS), U2.15 (A0), U2.16 (A1), U2.17 (A2); also elsewhere on the board
INT0: Q4.2 (S), R13.2; also elsewhere on the board
INT_5: Q4.3 (D), R16.2, U2.19 (INTB)
SCK0: Q3.2 (S); also elsewhere on the board
SCK_5: Q3.3 (D), R15.2, U2.12 (SCK)
SDA0: Q2.2 (S); also elsewhere on the board
SDA_5: Q2.3 (D), R14.2, U2.13 (SDA)

Parts:
C2, C3, C4, C5, C6: 100nF; C_0805_2012Metric_Pad1.18x1.45mm_HandSolder
J4: DE9_Receptacle_MountingHoles; DSUB-9_Female_Horizontal_P2.77x2.84mm_EdgePinOffset9.90mm_H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
U1: MAX3232; SOIC-16_3.9x9.9mm_P1.27mm

Connections:
+3V3: C3.1, U1.16 (VCC); also elsewhere on the board
CTS1: U1.9 (R2OUT); also elsewhere on the board
GND: C3.2, C4.2, C5.2, J4.0 (PAD), J4.5, U1.15 (GND); also elsewhere on the board
unnamed: C2.2, U1.1 (C1+)
unnamed: C2.1, U1.3 (C1-)
unnamed: C6.1, U1.4 (C2+)
unnamed: C6.2, U1.5 (C2-)
unnamed: J4.3, U1.13 (R1IN)
unnamed: J4.7, U1.8 (R2IN)
unnamed: J4.2, U1.14 (T1OUT)
unnamed: J4.8, U1.7 (T2OUT)
unnamed: C4.1, U1.2 (VS+)
unnamed: C5.1, U1.6 (VS-)
RTS1: U1.10 (T2IN); also elsewhere on the board
RxD1: U1.12 (R1OUT); also elsewhere on the board
TxD1: U1.11 (T1IN); also elsewhere on the board

Board: 4 copper layers, 68.0 x 99.0 mm, 48 parts (0 on the bottom side), 54 nets.

## KiCad design robot/kicad/auxboard/auxboard.kicad_pcb

Board: 2 copper layers, 65.0 x 70.0 mm, 10 parts (0 on the bottom side), 31 nets.

Parts:
A1: RaspberryPi_Pico; RaspberryPi_Pico_Common
H1, H2, H3, H4: MountingHole; MountingHole_3.2mm_M3
J1: Expansion; JST_XH_B6B-XH-A_1x06_P2.50mm_Vertical
J2: GPIO0; IDC-Header_2x05_P2.54mm_Vertical
J3: UART; PinHeader_1x03_P2.54mm_Vertical
J4: GPIO3; IDC-Header_2x05_P2.54mm_Vertical
J5: GPIO1; IDC-Header_2x05_P2.54mm_Vertical

Connections:
+3V3: J1.1, J4.2
+5V: A1.39 (VSYS), J1.2, J4.1
GND: A1.3 (GND), A1.8 (GND), A1.13 (GND), A1.18 (GND), A1.23 (GND), A1.28 (GND), A1.38 (GND), J1.4, J3.3, J4.8, J4.9, J4.10
unnamed: A1.35 (ADC_VREF), J4.3
unnamed: A1.33 (AGND), J4.7
unnamed: A1.1 (GPIO0), J3.1
unnamed: A1.2 (GPIO1), J3.2
unnamed: A1.4 (GPIO2), J2.1
unnamed: A1.5 (GPIO3), J2.2
unnamed: A1.6 (GPIO4), J2.3
unnamed: A1.7 (GPIO5), J2.4
unnamed: A1.9 (GPIO6), J2.5
unnamed: A1.10 (GPIO7), J2.6
unnamed: A1.14 (GPIO10), J2.7
unnamed: A1.15 (GPIO11), J2.8
unnamed: A1.16 (GPIO12), J2.9
unnamed: A1.17 (GPIO13), J2.10
unnamed: A1.19 (GPIO14), J5.1
unnamed: A1.20 (GPIO15), J5.2
unnamed: A1.21 (GPIO16), J5.3
unnamed: A1.22 (GPIO17), J5.4
unnamed: A1.24 (GPIO18), J5.5
unnamed: A1.25 (GPIO19), J5.6
unnamed: A1.26 (GPIO20), J5.7
unnamed: A1.27 (GPIO21), J5.8
unnamed: A1.29 (GPIO22), J5.9
unnamed: A1.31 (GPIO26_ADC0), J4.4
unnamed: A1.32 (GPIO27_ADC1), J4.5
unnamed: A1.34 (GPIO28_ADC2), J4.6
SCA: A1.12 (GPIO9), J1.6
SCL: A1.11 (GPIO8), J1.5

## KiCad design robot/kicad/mainboard/valiant-turtle-2.kicad_pcb

Parts:
A1: RaspberryPi_Pico_W; RaspberryPi_Pico_Common
C1, C2, C4: 100nF; C_0805_2012Metric_Pad1.18x1.45mm_HandSolder
C3: 100uF; CP_Elec_8x6.2
H1, H2, H3: Body_MountingHole; MountingHole_3.2mm_M3
H4, H5, H6, H7: Aux_MountingHole; MountingHole_3.2mm_M3
J1: Qwiic0 (NF); JST_SH_SM04B-SRSS-TB_1x04-1MP_P1.00mm_Horizontal
J2: USART Header; PinHeader_1x03_P2.54mm_Vertical
J3: Qwiic1; JST_SH_SM04B-SRSS-TB_1x04-1MP_P1.00mm_Horizontal
J4: Exp. Header; PinHeader_1x09_P2.54mm_Vertical
J5: Pen Servo Header; PinHeader_1x03_P2.54mm_Vertical
J6: Power Expansion; JST_XH_B6B-XH-A_1x06_P2.50mm_Vertical
R1, R2, R3, R4: 10K; R_0805_2012Metric_Pad1.20x1.40mm_HandSolder
U1: 24LC16BT-I/OT; SOT-23-5

Connections:
+3V3: C1.1, C2.1, C4.1, J1.2, J3.2, J6.1, R1.1, R2.2, R3.1, R4.1, U1.4 (VCC); also elsewhere on the board
+5V: A1.39 (VSYS), C3.1, J5.2, J6.2; also elsewhere on the board
+BATT: J6.3; also elsewhere on the board
/NEMA 17 Stepper Drivers/Enable: A1.9 (GPIO6); also elsewhere on the board
/NEMA 17 Stepper Drivers/LM_Dir: A1.6 (GPIO4); also elsewhere on the board
/NEMA 17 Stepper Drivers/LM_Step: A1.4 (GPIO2); also elsewhere on the board
/NEMA 17 Stepper Drivers/M0: A1.16 (GPIO12); also elsewhere on the board
/NEMA 17 Stepper Drivers/M1: A1.17 (GPIO13); also elsewhere on the board
/NEMA 17 Stepper Drivers/M2: A1.19 (GPIO14); also elsewhere on the board
/NEMA 17 Stepper Drivers/RM_Dir: A1.7 (GPIO5); also elsewhere on the board
/NEMA 17 Stepper Drivers/RM_Step: A1.5 (GPIO3); also elsewhere on the board
GND: A1.3 (GND), A1.8 (GND), A1.13 (GND), A1.18 (GND), A1.23 (GND), A1.28 (GND), A1.38 (GND), C1.2, C2.2, C3.2, C4.2, J1.1, J2.3, J3.1, J5.3, J6.4, U1.2 (GND), U1.5 (WP); also elsewhere on the board
LED_Din: A1.10 (GPIO7); also elsewhere on the board
unnamed: A1.1 (GPIO0), J2.1
unnamed: A1.2 (GPIO1), J2.2
unnamed: A1.22 (GPIO17), J4.1
unnamed: A1.24 (GPIO18), J4.2
unnamed: A1.25 (GPIO19), J4.3
unnamed: A1.26 (GPIO20), J4.4
unnamed: A1.27 (GPIO21), J4.5
unnamed: A1.29 (GPIO22), J4.6
unnamed: A1.31 (GPIO26_ADC0), J4.7
unnamed: A1.32 (GPIO27_ADC1), J4.8
unnamed: A1.34 (GPIO28_ADC2), J4.9
PWM_Servo: A1.21 (GPIO16), J5.1
SCL0: A1.12 (GPIO9), J1.4, R2.1, U1.1 (SCL); also elsewhere on the board
SCL1: A1.15 (GPIO11), J3.4, J6.5, R4.2
SDA0: A1.11 (GPIO8), J1.3, R1.2, U1.3 (SDA); also elsewhere on the board
SDA1: A1.14 (GPIO10), J3.3, J6.6, R3.2

Notes on the sheet:
JST-XH 2.54mm Connectors: 3 - WS2812 eyes 4 - Left and Right steppers 5 - Battery and switch
Configuration EEPROM

Parts:
C15, C16, C17, C18: 100nF; C_0805_2012Metric_Pad1.18x1.45mm_HandSolder
D3, D4, D5: WS2812B; LED_WS2812B_PLCC4_5.0x5.0mm_P3.2mm
J10: Eyes; JST_XH_B3B-XH-A_1x03_P2.50mm_Vertical
R6: 560R; R_0805_2012Metric_Pad1.20x1.40mm_HandSolder
U5: 74HC14; SO-14_3.9x8.65mm_P1.27mm

Connections:
+5V: C15.1, C16.1, C17.1, C18.1, D3.1 (VDD), D4.1 (VDD), D5.1 (VDD), J10.1, U5.14 (VCC); also elsewhere on the board
GND: C15.2, C16.2, C17.2, C18.2, D3.3 (VSS), D4.3 (VSS), D5.3 (VSS), J10.3, U5.3, U5.7 (GND); also elsewhere on the board
LED_Din: U5.1; also elsewhere on the board
unnamed: D3.4 (DIN), R6.2
unnamed: D3.2 (DOUT), D4.4 (DIN)
unnamed: D4.2 (DOUT), D5.4 (DIN)
unnamed: D5.2 (DOUT), J10.2
unnamed: R6.1, U5.12
unnamed: U5.6, U5.9
unnamed: U5.5, U5.10
unnamed: U5.4, U5.11
unnamed: U5.2, U5.13

Notes on the sheet:
Motor_Right
Motor_Left
Battery Ind.
Decoupling caps should be placed next to WS2812B modules

Parts:
A2, A3: DRV8825_Breakout; Pololu_Breakout-16_15.2x20.3mm
C5, C6: 100uF; CP_Elec_8x6.2
J7: Left Motor; JST_XH_B4B-XH-A_1x04_P2.50mm_Vertical
J8: Right Motor; JST_XH_B4B-XH-A_1x04_P2.50mm_Vertical

Connections:
+BATT: A2.16 (VMOT), A3.16 (VMOT), C5.1, C6.1; also elsewhere on the board
/NEMA 17 Stepper Drivers/Enable: A2.5 (~RST), A2.6 (~SLEEP), A3.5 (~RST), A3.6 (~SLEEP); also elsewhere on the board
/NEMA 17 Stepper Drivers/LM_Dir: A2.8 (DIR); also elsewhere on the board
/NEMA 17 Stepper Drivers/LM_Step: A2.7 (STEP); also elsewhere on the board
/NEMA 17 Stepper Drivers/M0: A2.2 (M0), A3.2 (M0); also elsewhere on the board
/NEMA 17 Stepper Drivers/M1: A2.3 (M1), A3.3 (M1); also elsewhere on the board
/NEMA 17 Stepper Drivers/M2: A2.4 (M2), A3.4 (M2); also elsewhere on the board
/NEMA 17 Stepper Drivers/RM_Dir: A3.8 (DIR); also elsewhere on the board
/NEMA 17 Stepper Drivers/RM_Step: A3.7 (STEP); also elsewhere on the board
GND: A2.1 (~EN), A2.9 (GND), A2.15 (GND), A3.1 (~EN), A3.9 (GND), A3.15 (GND), C5.2, C6.2; also elsewhere on the board
unnamed: A2.12 (A1), J7.3
unnamed: A2.11 (A2), J7.1
unnamed: A2.13 (B1), J7.2
unnamed: A2.14 (B2), J7.4
unnamed: A3.12 (A1), J8.3
unnamed: A3.11 (A2), J8.1
unnamed: A3.13 (B1), J8.2
unnamed: A3.14 (B2), J8.4

Notes on the sheet:
Mount close to VMOT

Parts:
C7, C11, C14: 100nF; C_0805_2012Metric_Pad1.18x1.45mm_HandSolder
C8: 100uF; CP_Elec_8x6.2
C9: 1000uF; CP_Elec_10x10.5
C10: 1uF; C_0805_2012Metric_Pad1.18x1.45mm_HandSolder
C12, C13: 10uF Tant; CP_EIA-3528-21_Kemet-B_Pad1.50x2.35mm_HandSolder
D1: SS34 3A; D_SMC_Handsoldering
D2: Power LED; LED_0805_2012Metric_Pad1.15x1.40mm_HandSolder
J9: Battery; JST_XH_B5B-XH-A_1x05_P2.50mm_Vertical
L1: 100uH 3A; Inductor_SDR1307
R5: 1K; R_0805_2012Metric_Pad1.20x1.40mm_HandSolder
U2: LM2576S-5; TO-263-5_TabPin3
U3: INA260; TSSOP-16_4.4x5mm_P0.65mm
U4: LM1117MP-3.3; SOT-223-3_TabPin2

Connections:
+3V3: C10.1, C13.1, C14.1, U3.10 (VS), U4.2 (VO); also elsewhere on the board
+5V: C9.1, C11.1, C12.1, L1.2, R5.1, U2.4 (FB), U4.3 (VI); also elsewhere on the board
+BATT: C7.1, C8.1, U2.1 (VIN), U3.14 (IN-), U3.15 (IN-), U3.16 (IN-); also elsewhere on the board
GND: C7.2, C8.2, C9.2, C10.2, C11.2, C12.2, C13.2, C14.2, D1.2 (A), D2.1 (K), J9.1, U2.3 (GND), U2.5 (~ON/OFF), U3.4 (A1), U3.5 (A0), U3.6 (GND), U3.11 (GND), U4.1 (GND); also elsewhere on the board
unnamed: D1.1 (K), L1.1, U2.2 (OUT)
unnamed: D2.2 (A), R5.2
unnamed: J9.3, J9.4
unnamed: J9.5, U3.1 (IN+), U3.2 (IN+), U3.3 (IN+), U3.12 (VBUS)
SCL0: U3.9 (SCL); also elsewhere on the board
SDA0: U3.8 (SDA); also elsewhere on the board

Notes on the sheet:
Battery is 4x18650 3V6 Nominal output is 14.4V
1 - Batt- 2 - NC 3 - Batt+ 4 - PWR SW in 5 - PWR SW out
Note: 5V supply maximum output 3000mA 3V3 supply maimum output 800mA

Notices in the files:
acorn_userport_adapter/kicad/parallel_adapter.kicad_pcb:
(c) 2024 Simon Inns
CC BY-SA 4.0
